# Keil uVision project XE164FN.uvproj, settings and files
target Target 1 (166/167)
  device: XE164FN-40F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE03FFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xC4FFFF) CLOCK(80000000) MOD167 MODV2
  output: XE164FN +hex
  group Source Group 1
    ./: START_V3.A66
  group Head Files
    ./Head/: ADC0.h ADC1.h CC2.h CCU60.h GPT1.h GPT2.h IO.h MAIN.h SCS.h WDT.h XE16xxNREGS.H
  group Source Files
    ./Source/: ADC0.c ADC1.c CC2.c CCU60.c GPT1.c GPT2.c IO.c SCS.c WDT.c
  group Main
    ./: MAIN.c
  group My Head Files
    ./My Head/: 74HC164.h ADC.h AT24C01.h config.h IIC.h other.h PWM.h time.h TM1629.h
  group My Source Files
    ./My Source/: 74HC164.c ADC.c AT24C01.c IIC.c other.c PWM.c time.c TM1629.c
